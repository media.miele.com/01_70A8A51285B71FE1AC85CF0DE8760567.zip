Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: dbcb23a5-6af2-4bab-b47f-1fda78dc9a14, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-10T22:31:28+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12941170_CH_KM8565FL:26I85652_CH_12941170_KM8565FL, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 620 mm; Height: 51 mm; Depth: 520 mm
Material: z_Miele_Design_Steel_Chrom, <Unnamed>, z_Miele_Design_Glass Black, z_Miele_Connection_Connection_Modul
Pset_BuildingElementProxyCommon - Reference: 26I85652_CH_12941170_KM8565FL; sets with these values: 2
